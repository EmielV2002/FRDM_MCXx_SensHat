# Keil uVision project freertos_blinky.uvprojx, settings and files
target freertos_blinky debug (6210000::V6.21::ARMCLANG)
  device: MCXA153VLH NXP
  pack: NXP.MCXA153_DFP.17.0.0
  cpu: CPUTYPE("Cortex-M33")
  output: freertos_blinky.out
  c flags: Optim=1 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: DEBUG, CPU_MCXA153VLH, MDKARM
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb -Wno-pedantic -Wno-declaration-after-statement -Wno-sign-conversion -Wno-unsafe-buffer-usage -Wno-missing-prototypes -Wno-date-time -Wno-extra-semi-stmt -Wno-padded -Wno-cast-align -Wno-missing-variable-declarations -Wno-missing-noreturn -Wno-covered-switch-default
  c include: ..;..\..\..\..\..\..\CMSIS\Core\Include;..\..\..\..\..\..\rtos\freertos\freertos-kernel\include;..\..\..\..\..\..\rtos\freertos\freertos-kernel\portable\ARMv8M\non_secure;..\..\..\..\..\..\rtos\freertos\freertos-kernel\portable\ARMv8M\non_secure\portable\GCC\ARM_CM33_NTZ
  asm define: CPU_LPC55S69JBD100_cm33_core0, DEBUG,__CC_ARM,KEIL, DEBUG
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x20000
  memory RVCT4: ROM 0x3000000 size 0x2000
  memory RVCT5: ROM 0x13000000 size 0x2000
  memory RVCT6: RAM 0x4000000 size 0x2000
  memory RVCT7: RAM 0x14000000 size 0x2000
  memory RVCT8: RAM 0x4002000 size 0x1000
  memory RVCT9: RAM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x6000
  scatter file: MCXA153_flash.scf
  link misc: --remove --entry=Reset_Handler --diag_suppress 6314
  group source
    ../: main.c FreeRTOSConfig.h gpio_output.c gpio_output.h
  group doc
    ../: readme.md
  group device
    ../../../../../../devices/MCXA153/: MCXA153.h system_MCXA153.c system_MCXA153.h
  group FreeRTOS
    ../../../../../../rtos/freertos/freertos-kernel/: croutine.c event_groups.c LICENSE.md list.c queue.c README.md stream_buffer.c tasks.c timers.c
  group FreeRTOS_portable
    ../../../../../../rtos/freertos/freertos-kernel/portable/MemMang/: heap_4.c
    ../../../../../../rtos/freertos/freertos-kernel/portable/GCC/ARM_CM33_NTZ/non_secure/: port.c portasm.c
  group runtime_stats
    ../: runtime_stats.c runtime_stats.h
  group serial
    ../: serial.c serial.h
  group startup
    ../../../../../../devices/MCXA153/arm/: startup_MCXA153.S
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
target freertos_blinky release (6210000::V6.21::ARMCLANG)
  device: MCXA153VLH NXP
  pack: NXP.MCXA153_DFP.17.0.0
  cpu: CPUTYPE("Cortex-M33")
  output: freertos_blinky.out
  c flags: Optim=5 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: NDEBUG, CPU_MCXA153VLH, MDKARM
  c misc: as above
  c include: as above
  asm define: CPU_LPC55S69JBD100_cm33_core0, NDEBUG,__CC_ARM,KEIL, NDEBUG
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x20000
  memory RVCT4: ROM 0x3000000 size 0x2000
  memory RVCT5: ROM 0x13000000 size 0x2000
  memory RVCT6: RAM 0x4000000 size 0x2000
  memory RVCT7: RAM 0x14000000 size 0x2000
  memory RVCT8: RAM 0x4002000 size 0x1000
  memory RVCT9: RAM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x6000
  scatter file: MCXA153_flash.scf
  link misc: --remove --entry=Reset_Handler --diag_suppress 6314
