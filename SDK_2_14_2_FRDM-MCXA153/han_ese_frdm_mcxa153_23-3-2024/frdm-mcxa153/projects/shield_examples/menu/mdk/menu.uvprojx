# Keil uVision project menu.uvprojx, settings and files
target menu debug (6210000::V6.21::ARMCLANG)
  device: MCXA153VLH NXP
  pack: NXP.MCXA153_DFP.17.0.0
  cpu: CPUTYPE("Cortex-M33")
  output: menu.out
  c flags: Optim=1 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: DEBUG, CPU_MCXA153VLH, MDKARM
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb -Wno-pedantic -Wno-declaration-after-statement -Wno-sign-conversion -Wno-unsafe-buffer-usage -Wno-missing-prototypes -Wno-date-time
  c include: ..;../../../../../../CMSIS/Core/Include;..\Unity-master\src
  asm define: CPU_LPC55S69JBD100_cm33_core0, DEBUG,__CC_ARM,KEIL, DEBUG
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x20000
  memory RVCT4: ROM 0x3000000 size 0x2000
  memory RVCT5: ROM 0x13000000 size 0x2000
  memory RVCT6: RAM 0x4000000 size 0x2000
  memory RVCT7: RAM 0x14000000 size 0x2000
  memory RVCT8: RAM 0x4002000 size 0x1000
  memory RVCT9: RAM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x6000
  scatter file: MCXA153_flash.scf
  link misc: --remove --entry=Reset_Handler --diag_suppress 6314
  group source
    ../: bitmaps.c bitmaps.h encoder.c encoder.h fifo.c fifo.h fonts.c fonts.h fsm.c fsm.h lpi2c0_controller_dma.c lpi2c0_controller_dma.h lpuart0_interrupt.c lpuart0_interrupt.h main.c neopixel_flexpwm.c neopixel_flexpwm.h ssd1306.c ssd1306.h retarget.c rgb_led.c rgb_led.h shiftregister.c shiftregister.h switches.c switches.h
  group doc
    ../: readme.md
  group device
    ../../../../../../devices/MCXA153/: MCXA153.h system_MCXA153.c system_MCXA153.h
  group startup
    ../../../../../../devices/MCXA153/arm/: startup_MCXA153.S
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
target menu release (6210000::V6.21::ARMCLANG)
  device: MCXA153VLH NXP
  pack: NXP.MCXA153_DFP.17.0.0
  cpu: CPUTYPE("Cortex-M33")
  output: menu.out
  c flags: Optim=5 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: NDEBUG, CPU_MCXA153VLH, MDKARM
  c misc: as above
  c include: ..;../../../../../../CMSIS/Core/Include;..\Unity-master\src
  asm define: CPU_LPC55S69JBD100_cm33_core0, NDEBUG,__CC_ARM,KEIL, NDEBUG
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x20000
  memory RVCT4: ROM 0x3000000 size 0x2000
  memory RVCT5: ROM 0x13000000 size 0x2000
  memory RVCT6: RAM 0x4000000 size 0x2000
  memory RVCT7: RAM 0x14000000 size 0x2000
  memory RVCT8: RAM 0x4002000 size 0x1000
  memory RVCT9: RAM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x6000
  scatter file: MCXA153_flash.scf
  link misc: --remove --entry=Reset_Handler --diag_suppress 6314
software components: Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0
