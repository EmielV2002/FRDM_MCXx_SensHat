# IAR project dev_suspend_resume_hid_mouse_bm.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MCXA153 NXP MCXA153
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; _DEBUG=1; CPU_MCXA153VLH; USB_STACK_BM; FSL_OSA_BM_TASK_ENABLE=0; FSL_OSA_BM_TIMER_CONFIG=0; SDK_DEBUGCONSOLE=1; MCUXPRESSO_SDK; SDK_OS_BAREMETAL
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe188,Pe069
  ICCARM.CCIncludePath2: ..; ../../../../../../components/gpio; ../../../../../../components/timer; ../../../../../../components/lists; ../../../../../../components/uart; ../../../../../../devices/MCXA153; ../../../../../../devices/MCXA153/drivers; ../../../../../../middleware/usb/device; ../../../../../../middleware/usb/include; ../../../../../../devices/MCXA153/utilities/str; ../../../../../../devices/MCXA153/utilities/debug_console_lite; ../../../../../../CMSIS/Core/Include; ../../../../../../components/osa
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: dev_suspend_resume_hid_mouse_bm.out
  ILINK.IlinkConfigDefines: __stack_size__=0x800; __heap_size__=0x800
  ILINK.IlinkIcfFile: MCXA153_flash.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; _DEBUG=0; CPU_MCXA153VLH; USB_STACK_BM; FSL_OSA_BM_TASK_ENABLE=0; FSL_OSA_BM_TIMER_CONFIG=0; SDK_DEBUGCONSOLE=1; MCUXPRESSO_SDK; SDK_OS_BAREMETAL
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group source
    ../: mouse.c mouse.h usb_device_descriptor.c usb_device_descriptor.h usb_device_config.h
  group doc
    ../: readme.txt readme.txt
  group usb/device/class
    ../: usb_device_class.c usb_device_class.h
  group usb/device/class/hid
    ../: usb_device_hid.c usb_device_hid.h
  group usb/device/source
    ../: usb_device_ch9.c usb_device_ch9.h
    ../../../../../../middleware/usb/device/: usb_device_dci.c usb_device_dci.h usb_device_dci.h
  group usb/device/source/khci
    ../../../../../../middleware/usb/device/: usb_device_khci.c usb_device_khci.h
  group usb/device/include
    ../../../../../../middleware/usb/device/: usb_device.h usb_device.h
  group usb/include
    ../../../../../../middleware/usb/include/: usb.h usb.h usb_misc.h usb_spec.h
  group component/gpio
    ../../../../../../components/gpio/: fsl_adapter_gpio.h fsl_adapter_gpio.c
  group component/timer
    ../../../../../../components/timer/: fsl_adapter_timer.h fsl_adapter_lptmr.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/osa
    ../../../../../../components/osa/: fsl_os_abstraction.h fsl_os_abstraction_config.h fsl_os_abstraction_bm.h fsl_os_abstraction_bm.c
  group device
    ../../../../../../devices/MCXA153/: fsl_device_registers.h MCXA153.h MCXA153_features.h system_MCXA153.c system_MCXA153.h
  group startup
    ../../../../../../devices/MCXA153/iar/: startup_MCXA153.s
  group drivers
    ../../../../../../devices/MCXA153/drivers/: fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_gpio.h fsl_gpio.c fsl_inputmux_connections.h fsl_lpuart.h fsl_lpuart.c fsl_port.h fsl_reset.h fsl_reset.c fsl_spc.h fsl_spc.c fsl_lptmr.c fsl_lptmr.h
  group utilities
    ../../../../../../devices/MCXA153/utilities/debug_console_lite/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h
    ../../../../../../devices/MCXA153/utilities/str/: fsl_str.c fsl_str.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
