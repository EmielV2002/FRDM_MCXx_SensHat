# Keil uVision project mc_pmsm.uvprojx, settings and files
target mc_pmsm debug (6180000::V6.18::ARMCLANG)
  device: MCXA153VLH NXP
  pack: NXP.MCXA153_DFP.17.0.0
  cpu: CPUTYPE("Cortex-M33")
  output: mc_pmsm.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CPU_MCXA153VLH, RTCESL_PQ_OFF=1, MC_EXAMPLE, MCUXPRESSO_SDK, PMSM_SNSLESS, MID_EN
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;../../../../../../devices/MCXA153/drivers;../../../../../../middleware/motor_control/pmsm/pmsm_frac/mc_algorithms/mcaa_lib/cm33nodsp_mdk/Include;../../../../../../middleware/rtcesl/CM33NODSP_RTCESL_4.7.1_KEIL/AMCLIB/Include;../../../../../../middleware/rtcesl/CM33NODSP_RTCESL_4.7.1_KEIL/GDFLIB/Include;../../../../../../middleware/rtcesl/CM33NODSP_RTCESL_4.7.1_KEIL/GFLIB/Include;../../../../../../middleware/rtcesl/CM33NODSP_RTCESL_4.7.1_KEIL/GMCLIB/Include;../../../../../../middleware/rtcesl/CM33NODSP_RTCESL_4.7.1_KEIL/MLIB/Include;../../../../../../middleware/motor_control/pmsm/pmsm_frac/mc_drivers;../../../../../../middleware/motor_control/freemaster/pmsm_frac/mcat;../../../../../../middleware/motor_control/pmsm/pmsm_frac/mc_algorithms;../../../../../../middleware/motor_control/pmsm/pmsm_frac/state_machine;../../../../../../middleware/motor_control/pmsm/pmsm_frac/mc_state_machine;../../../../../../middleware/motor_control/pmsm/pmsm_frac;../../../../../../middleware/motor_control/pmsm/pmsm_frac/mc_identification;../../../../../../devices/MCXA153;../../../../../../devices/MCXA153/utilities/str;../../../../../../devices/MCXA153/utilities/debug_console_lite;../../../../../../components/uart;../../../../../../components/lists;../../../../../../middleware/freemaster/src/common;../../../../../../middleware/freemaster/src/platforms/gen32le;../../../../../../middleware/freemaster/src/drivers/mcuxsdk/can;../../../../../../middleware/freemaster/src/drivers/mcuxsdk/serial;../../../../../../CMSIS/Core/Include
  asm define: CPU_LPC55S69JBD100_cm33_core0, DEBUG,__CC_ARM,KEIL, DEBUG
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x20000
  memory RVCT4: ROM 0x3000000 size 0x2000
  memory RVCT5: ROM 0x13000000 size 0x2000
  memory RVCT6: RAM 0x4000000 size 0x2000
  memory RVCT7: RAM 0x14000000 size 0x2000
  memory RVCT8: RAM 0x4002000 size 0x1000
  memory RVCT9: RAM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x6000
  scatter file: MCXA153_flash.scf
  link misc: ../../../../../../middleware/motor_control/pmsm/pmsm_frac/mc_algorithms/mcaa_lib/cm33nodsp_mdk/mcaa_lib.lib ../../../../../../middleware/rtcesl/CM33NODSP_RTCESL_4.7.1_KEIL/AMCLIB/AMCLIB.lib ../../../../../../middleware/rtcesl/CM33NODSP_RTCESL_4.7.1_KEIL/GFLIB/GFLIB.lib ../../../../../../middleware/rtcesl/CM33NODSP_RTCESL_4.7.1_KEIL/GDFLIB/GDFLIB.lib ../../../../../../middleware/rtcesl/CM33NODSP_RTCESL_4.7.1_KEIL/GMCLIB/GMCLIB.lib ../../../../../../middleware/rtcesl/CM33NODSP_RTCESL_4.7.1_KEIL/MLIB/MLIB.lib --remove --entry=Reset_Handler --diag_suppress 6314
  group motor_control/freemaster
    ../../../../../../middleware/motor_control/freemaster/: pmsm_frac.pmpx
  group motor_control/docs
    ../../../../../../middleware/motor_control/docs/: PMSMFRDMMCXA153.pdf Release_notes.pdf
  group source
    ../: main.c m1_pmsm_appconfig.h mc_periph_init.c freemaster_cfg.h mc_periph_init.h
  group board
    ../: pin_mux.c pin_mux.h clock_config.h clock_config.c peripherals.h peripherals.c board.c board.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../devices/MCXA153/drivers/: fsl_port.h fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_reset.h fsl_reset.c fsl_lpuart.h fsl_lpuart.c fsl_lpadc.c fsl_lpadc.h fsl_lpcmp.c fsl_lpcmp.h fsl_inputmux.h fsl_inputmux.c fsl_gpio.h fsl_gpio.c fsl_spc.h fsl_spc.c fsl_inputmux_connections.h
  group motor_control/pmsm/pmsm_frac/mc_algorithms/mcaa_lib/cm33nodsp_mdk/Include
    ../../../../../../middleware/motor_control/pmsm/pmsm_frac/mc_algorithms/mcaa_lib/cm33nodsp_mdk/Include/: MCAA_EstimRL.h mcaa_lib.h
  group rtcesl/CM33NODSP_RTCESL_4.7.1_KEIL/AMCLIB/Include
    ../../../../../../middleware/rtcesl/CM33NODSP_RTCESL_4.7.1_KEIL/AMCLIB/Include/: amclib.h AMCLIB_AngleTrackObsrv_F32.h AMCLIB_CtrlFluxWkng_A32.h AMCLIB_PMSMBemfObsrvAB_A32.h AMCLIB_PMSMBemfObsrvDQ_A32.h AMCLIB_TrackObsrv_F32.h amclib_types.h
  group rtcesl/CM33NODSP_RTCESL_4.7.1_KEIL/GDFLIB/Include
    ../../../../../../middleware/rtcesl/CM33NODSP_RTCESL_4.7.1_KEIL/GDFLIB/Include/: gdflib.h GDFLIB_FilterExp_F32.h GDFLIB_FilterIIR1_F32.h GDFLIB_FilterIIR1_F32_Asmi.h GDFLIB_FilterIIR2_F32.h GDFLIB_FilterIIR3_F32.h GDFLIB_FilterIIR4_F32.h GDFLIB_FilterMA_A32.h gdflib_types.h
  group rtcesl/CM33NODSP_RTCESL_4.7.1_KEIL/GFLIB/Include
    ../../../../../../middleware/rtcesl/CM33NODSP_RTCESL_4.7.1_KEIL/GFLIB/Include/: gflib.h GFLIB_Acos_F16.h GFLIB_Asin_F16.h GFLIB_Atan_F32.h GFLIB_AtanYX_F16.h GFLIB_AtanYXPQ_F16.h GFLIB_CtrlBetaIPDp_A32.h GFLIB_CtrlBetaIPp_A32.h GFLIB_CtrlPIDp_A32.h GFLIB_CtrlPIp_A32.h GFLIB_DFlexRamp_A32.h GFLIB_DRamp_F16.h GFLIB_DRamp_F32.h GFLIB_FlexRamp_A32.h GFLIB_FlexSRamp_A32.h GFLIB_Hyst_F16_Asmi.h GFLIB_Integrator_A32.h GFLIB_Limit_F16.h GFLIB_Limit_F32.h GFLIB_LowerLimit_F16.h GFLIB_LowerLimit_F32.h GFLIB_Lut_F16_Asmi.h GFLIB_Lut_F32.h GFLIB_LutPer_F16_Asmi.h GFLIB_LutPer_F32.h GFLIB_Ramp_F16.h GFLIB_Ramp_F32.h GFLIB_SinCos_F32.h GFLIB_SinCosPQ_F32.h GFLIB_Sqrt_F16.h GFLIB_Sqrt_F32.h GFLIB_SqrtPQ_F16.h GFLIB_SqrtPQ_F32.h GFLIB_Tan_F32.h gflib_types.h GFLIB_UpperLimit_F16.h GFLIB_UpperLimit_F32.h GFLIB_VectorLimit_F16.h
  group rtcesl/CM33NODSP_RTCESL_4.7.1_KEIL/GMCLIB/Include
    ../../../../../../middleware/rtcesl/CM33NODSP_RTCESL_4.7.1_KEIL/GMCLIB/Include/: gmclib.h GMCLIB_Clark_F16_Asmi.h GMCLIB_Decoupling_A32.h GMCLIB_DTCompLut1D_F16.h GMCLIB_ElimDcBusRip_A32_Asmi.h GMCLIB_ElimDcBusRip_F16_Asmi.h GMCLIB_Park_F16_Asmi.h GMCLIB_Svm_F16.h gmclib_types.h
  group rtcesl/CM33NODSP_RTCESL_4.7.1_KEIL/MLIB/Include
    ../../../../../../middleware/rtcesl/CM33NODSP_RTCESL_4.7.1_KEIL/MLIB/Include/: asm_mac.h mlib.h MLIB_Abs_F16.h MLIB_Abs_F16_Asmi.h MLIB_Abs_F32.h MLIB_Abs_F32_Asmi.h MLIB_Add_A32.h MLIB_Add_A32_Asmi.h MLIB_Add_F16.h MLIB_Add_F16_Asmi.h MLIB_Add_F32.h MLIB_Add_F32_Asmi.h MLIB_Add4_F16_Asmi.h MLIB_Add4_F32_Asmi.h MLIB_BiShift_F16.h MLIB_BiShift_F32.h MLIB_Clb_F16.h MLIB_Clb_F32.h MLIB_Conv_F32.h MLIB_Div_A32.h MLIB_Div_F16.h MLIB_Div_F32.h MLIB_Div1Q_A32.h MLIB_Div1Q_F16.h MLIB_Div1Q_F32.h MLIB_Log2_U16.h MLIB_Mac_A32.h MLIB_Mac_F16.h MLIB_Mac_F16_Asmi.h MLIB_Mac_F32.h MLIB_Mac_F32_Asmi.h MLIB_Mac4_F32.h MLIB_Mac4Rnd_F16.h MLIB_Mac4Rnd_F16_Asmi.h MLIB_Mac4Rnd_F32.h MLIB_Mac4Rnd_F32_Asm.h MLIB_MacRnd_A32.h MLIB_MacRnd_F16.h MLIB_MacRnd_F16_Asmi.h MLIB_MacRnd_F32.h MLIB_MacRnd_F32_Asmi.h MLIB_Mnac_A32.h MLIB_Mnac_F16.h MLIB_Mnac_F16_Asmi.h MLIB_Mnac_F32.h MLIB_Mnac_F32_Asmi.h MLIB_MnacRnd_A32.h MLIB_MnacRnd_F16.h MLIB_MnacRnd_F16_Asmi.h MLIB_MnacRnd_F32.h MLIB_MnacRnd_F32_Asmi.h MLIB_Msu_A32.h MLIB_Msu_F16.h MLIB_Msu_F16_Asmi.h MLIB_Msu_F32.h MLIB_Msu_F32_Asmi.h MLIB_Msu4_F32.h MLIB_Msu4Rnd_F16.h MLIB_Msu4Rnd_F16_Asmi.h MLIB_Msu4Rnd_F32.h MLIB_Msu4Rnd_F32_Asm.h MLIB_MsuRnd_A32.h MLIB_MsuRnd_F16.h MLIB_MsuRnd_F16_Asmi.h MLIB_MsuRnd_F32.h MLIB_MsuRnd_F32_Asmi.h MLIB_Mul_A32.h MLIB_Mul_A32_Asmi.h MLIB_Mul_F16.h MLIB_Mul_F16_Asmi.h MLIB_Mul_F32.h MLIB_Mul_F32_Asmi.h MLIB_MulRnd_A32.h MLIB_MulRnd_A32_Asmi.h MLIB_MulRnd_F16.h MLIB_MulRnd_F16_Asmi.h MLIB_MulRnd_F32.h MLIB_MulRnd_F32_Asmi.h MLIB_Neg_F16.h MLIB_Neg_F16_Asmi.h MLIB_Neg_F32.h MLIB_Neg_F32_Asmi.h MLIB_PQ.h MLIB_Rcp_A32.h MLIB_Rcp1Q_A32.h MLIB_Rnd_F32.h MLIB_Rnd_F32_Asmi.h MLIB_Sat_A32_Asmi.h MLIB_Shift_F16.h MLIB_Shift_F16_Asmi.h MLIB_Shift_F32.h MLIB_Shift_F32_Asmi.h MLIB_Sign_F16_Asmi.h MLIB_Sign_F32_Asmi.h MLIB_Sub_A32.h MLIB_Sub_F16.h MLIB_Sub_F16_Asmi.h MLIB_Sub_F32.h MLIB_Sub_F32_Asmi.h MLIB_Sub_F64.h MLIB_Sub4_F16_Asmi.h MLIB_Sub4_F32_Asmi.h mlib_types.h RTCESL_cfg.h
  group motor_control/pmsm/pmsm_frac/mc_drivers
    ../../../../../../middleware/motor_control/pmsm/pmsm_frac/mc_drivers/: mcdrv_adc_mcax.c mcdrv_adc_mcax.h mcdrv_pwm3ph_epwm.c mcdrv_pwm3ph_epwm.h
  group motor_control/freemaster/pmsm_frac/fm_control
    ../../../../../../middleware/motor_control/freemaster/pmsm_frac/fm_control/: control_page_config.js control_page_scripts.js FM_control_M1.html jquery-1.11.1.min.js jqxbuttons.js jqxcore.js jqxdraw.js jqxgauge.js jqxlistmenu.js jqxmenu.js jqxnotification.js jqxpanel.js jqxradiobutton.js jqxscrollbar.js jqxslider.js jqxswitchbutton.js jqxtooltip.js jqxwindow.js logo.png
  group motor_control/freemaster/pmsm_frac/fm_control/styles/images
    ../../../../../../middleware/motor_control/freemaster/pmsm_frac/fm_control/styles/images/: backgroundTop.png backImage.png bg_black.png bg_black_horizontal.png bg_blackhover.png bg_blackhover_horizontal.png bg_blackpressed.png bg_blackpressed_horizontal.png bg_blueenergy.png bg_darkblue.png bg_darkbluehover.png bg_darkbluepressed.png black_gradient.png blackbackground.png check_black.png check_blue.png check_blue_indeterminate.png check_disabled.png check_indeterminate_black.png check_indeterminate_disabled.png check_indeterminate_white.png check_lightblue.png check_lightblue_indeterminate.png check_white.png close.png close_black.png close_blue.png close_white.png crosshair.png crosshair-white.png darkred_gradient.png drag.png dragcancel.png error.png filter.png html_editor.png html_editor_white.png icon-calendar.png icon-calendar-white.png icon-cancel.png icon-cancel-white.png icon-delete.png icon-delete-white.png icon-down.png icon-down-blue.png icon-down-transparent.png icon-down-white.png icon-edit.png icon-edit-white.png icon-first.png icon-first-blue.png icon-first-transparent.png icon-first-white.png icon-last.png icon-last-blue.png icon-last-transparent.png icon-last-white.png icon-left.png icon-left-blue.png icon-left-transparent.png icon-left-white.png icon-menu-minimized.png icon-menu-minimized-white.png icon-right.png icon-right-blue.png icon-right-transparent.png icon-right-white.png icon-save.png icon-save-white.png icon-showpassword.png icon-showpassword-white.png icon-up.png icon-up-blue.png icon-up-transparent.png icon-up-white.png info.png loader.gif loader-small.gif mail.png menubutton.png metro-icon-down.png metro-icon-down-white.png metro-icon-first.png metro-icon-first-white.png metro-icon-last.png metro-icon-last-white.png metro-icon-left.png metro-icon-left-white.png metro-icon-right.png metro-icon-right - Copy.png metro-icon-right-white.png metro-icon-up.png metro-icon-up-white.png multi-arrow.gif office-icon-down.png office-icon-first.png office-icon-last.png office-icon-left.png office-icon-right.png office-icon-up.png plus.png plus_white.png pointer.png rangebar_classic.png rangebar_darkblue.png rangebar_shinyblack.png rangebar_summer.png red_arrow_down.png red_arrow_up.png red_gradient.png roundbg_check_black.png roundbg_check_disabled.png roundbg_check_indeterminate.png roundbg_check_white.png roundbg_classic_hover.png roundbg_classic_normal.png roundbg_disabled.png search.png search_white.png sortasc.png sortascbutton.png sortdesc.png sortdescbutton.png sortremove.png star.png star_disabled.png star_hover.png success.png tick.png time.png track_classic.png track_darkblue.png track_shinyblack.png track_summer.png warning.png wp_check_indeterminate_white.png wp_check_white.png
  group motor_control/freemaster/pmsm_frac/fm_control/styles
    ../../../../../../middleware/motor_control/freemaster/pmsm_frac/fm_control/styles/: jqx.energyblue jqx.base.css jqx.energyblue.css jqx.energyblue.txt
  group motor_control/freemaster/pmsm_frac/mcat/assets
    ../../../../../../middleware/motor_control/freemaster/pmsm_frac/mcat/assets/: NXP_logo_RGB_web.jpg nxp-logo-small-121x52.png speedfocwolswbemf.gif
  group motor_control/freemaster/pmsm_frac/mcat/css
    ../../../../../../middleware/motor_control/freemaster/pmsm_frac/mcat/css/: app.css
  group motor_control/freemaster/pmsm_frac/mcat/js
    ../../../../../../middleware/motor_control/freemaster/pmsm_frac/mcat/js/: chunk.js chunk.js.map mcat.js mcat.js.map
  group motor_control/freemaster/pmsm_frac/mcat/license
    ../../../../../../middleware/motor_control/freemaster/pmsm_frac/mcat/license/: LA_OPT_NXP_Software_License.txt SW-Content-Register.txt
  group motor_control/freemaster/pmsm_frac/mcat
    ../../../../../../middleware/motor_control/freemaster/pmsm_frac/mcat/: freemaster-client.js index.html init.js simple-jsonrpc-js.js m1_pmsm_appconfig.h
  group motor_control/pmsm/pmsm_frac/mc_algorithms
    ../../../../../../middleware/motor_control/pmsm/pmsm_frac/mc_algorithms/: pmsm_control.c pmsm_control.h pmsm_control.c pmsm_control.h
  group motor_control/pmsm/pmsm_frac/state_machine
    ../../../../../../middleware/motor_control/pmsm/pmsm_frac/state_machine/: state_machine.c state_machine.h
  group motor_control/pmsm/pmsm_frac/mc_state_machine
    ../../../../../../middleware/motor_control/pmsm/pmsm_frac/mc_state_machine/: m1_sm_snsless.c m1_sm_snsless.h sm_common.h
  group motor_control/pmsm/pmsm_frac
    ../../../../../../middleware/motor_control/pmsm/pmsm_frac/: fm_tsa_pmsm.c
  group motor_control/pmsm/pmsm_frac/mc_identification
    ../../../../../../middleware/motor_control/pmsm/pmsm_frac/mc_identification/: mid_def.h mid_sm_states.c mid_sm_states.h pp_measure.c pp_measure.h m1_mid_switch.c m1_mid_switch.h
  group device
    ../../../../../../devices/MCXA153/: fsl_device_registers.h MCXA153.h MCXA153_features.h system_MCXA153.c system_MCXA153.h
  group startup
    ../../../../../../devices/MCXA153/arm/: startup_MCXA153.S
  group utilities
    ../../../../../../devices/MCXA153/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MCXA153/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group freemaster
    ../../../../../../middleware/freemaster/src/common/: freemaster.h freemaster_appcmd.c freemaster_defcfg.h freemaster_pipes.c freemaster_private.h freemaster_protocol.c freemaster_protocol.h freemaster_rec.c freemaster_rec.h freemaster_scope.c freemaster_tsa.c freemaster_tsa.h freemaster_ures.c freemaster_ures.h freemaster_utils.c freemaster_utils.h freemaster_can.c freemaster_can.h freemaster_sha.c freemaster_pdbdm.c freemaster_serial.c freemaster_serial.h freemaster_net.c freemaster_net.h
  group freemaster/platforms
    ../../../../../../middleware/freemaster/src/platforms/gen32le/: freemaster_gen32le.h
  group freemaster/drivers
    ../../../../../../middleware/freemaster/src/drivers/mcuxsdk/can/: freemaster_flexcan.c freemaster_flexcan.h freemaster_mscan.c freemaster_mscan.h freemaster_mcan.c freemaster_mcan.h
    ../../../../../../middleware/freemaster/src/drivers/mcuxsdk/serial/: freemaster_serial_uart.c freemaster_serial_uart.h freemaster_serial_lpsci.c freemaster_serial_lpsci.h freemaster_serial_lpuart.c freemaster_serial_lpuart.h freemaster_serial_usart.c freemaster_serial_usart.h freemaster_serial_miniusart.c freemaster_serial_miniusart.h freemaster_serial_usb.c freemaster_serial_usb.h
    ../../../../../../middleware/freemaster/src/drivers/mcuxsdk/network/: freemaster_net_segger_rtt.c freemaster_net_segger_rtt.h freemaster_net_lwip_udp.c freemaster_net_lwip_udp.h freemaster_net_lwip_tcp.c freemaster_net_lwip_tcp.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
target mc_pmsm release (6130001::V6.13.1::.\ARMCLANG)
  device: MCXA153VLH NXP
  pack: NXP.MCXA153_DFP.17.0.0
  cpu: CPUTYPE("Cortex-M33")
  output: mc_pmsm.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, CPU_MCXA153VLH, RTCESL_PQ_OFF=1, MC_EXAMPLE, MCUXPRESSO_SDK, PMSM_SNSLESS, MID_EN
  c misc: as above
  c include: as above
  asm define: CPU_LPC55S69JBD100_cm33_core0, NDEBUG,__CC_ARM,KEIL, NDEBUG
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x20000
  memory RVCT4: ROM 0x3000000 size 0x2000
  memory RVCT5: ROM 0x13000000 size 0x2000
  memory RVCT6: RAM 0x4000000 size 0x2000
  memory RVCT7: RAM 0x14000000 size 0x2000
  memory RVCT8: RAM 0x4002000 size 0x1000
  memory RVCT9: RAM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x6000
  scatter file: MCXA153_flash.scf
  link misc: as above
