# IAR project cmsis_lpspi_edma_b2b_transfer_master.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MCXA153 NXP MCXA153
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_MCXA153VLH; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe188,Pe069
  ICCARM.CCIncludePath2: ..; ../../../../../../../devices/MCXA153/drivers; ../../../../../../../devices/MCXA153/cmsis_drivers; ../../../../../../../devices/MCXA153; ../../../../../../../devices/MCXA153/utilities/str; ../../../../../../../devices/MCXA153/utilities/debug_console_lite; ../../../../../../../components/uart; ../../../../../../../components/lists; ../../../../../../../CMSIS/Driver/Include; ../../../../../../../devices/MCXA153/template; ../../../../../../../CMSIS/Core/Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: cmsis_lpspi_edma_b2b_transfer_master.out
  ILINK.IlinkIcfFile: MCXA153_flash.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MCXA153VLH; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
  group source
    ../: cmsis_lpspi_edma_b2b_transfer_master.c
  group board
    ../: pin_mux.c pin_mux.h RTE_Device.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.md
  group drivers
    ../../../../../../../devices/MCXA153/drivers/: fsl_edma_soc.h fsl_edma_soc.c fsl_edma.h fsl_edma_core.h fsl_edma.c fsl_lpspi_edma.h fsl_lpspi_edma.c fsl_port.h fsl_clock.h fsl_clock.c fsl_gpio.h fsl_gpio.c fsl_lpuart.h fsl_lpuart.c fsl_lpspi.c fsl_lpspi.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_reset.h fsl_reset.c fsl_spc.h fsl_spc.c
    ../../../../../../../devices/MCXA153/cmsis_drivers/: fsl_lpspi_cmsis.h fsl_lpspi_cmsis.c
  group device
    ../../../../../../../devices/MCXA153/: fsl_device_registers.h MCXA153.h MCXA153_features.h system_MCXA153.c system_MCXA153.h
  group startup
    ../../../../../../../devices/MCXA153/iar/: startup_MCXA153.s
  group utilities
    ../../../../../../../devices/MCXA153/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../../devices/MCXA153/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group component/uart
    ../../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/lists
    ../../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group CMSIS_driver/Include
    ../../../../../../../CMSIS/Driver/Include/: Driver_SPI.h Driver_Common.h
  group CMSIS
    ../../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
