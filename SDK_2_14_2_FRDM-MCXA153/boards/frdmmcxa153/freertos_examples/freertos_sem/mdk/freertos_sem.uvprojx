# Keil uVision project freertos_sem.uvprojx, settings and files
target freertos_sem debug (6180000::V6.18::ARMCLANG)
  device: MCXA153VLH NXP
  pack: NXP.MCXA153_DFP.17.0.0
  cpu: CPUTYPE("Cortex-M33")
  output: freertos_sem.out
  AfterMake: fromelf.exe --output "$Lfreertos_sem.bin" --bincombined "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CPU_MCXA153VLH, MCUXPRESSO_SDK, SDK_OS_FREE_RTOS
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;../../../../../rtos/freertos/freertos-kernel/portable/GCC/ARM_CM33_NTZ/non_secure;../../../../../devices/MCXA153/drivers;../../../../../devices/MCXA153;../../../../../devices/MCXA153/utilities/str;../../../../../devices/MCXA153/utilities/debug_console_lite;../../../../../components/uart;../../../../../components/lists;../../../../../rtos/freertos/freertos-kernel/include;../../../../../CMSIS/Core/Include
  asm define: CPU_LPC55S69JBD100_cm33_core0, DEBUG,__CC_ARM,KEIL, DEBUG
  asm include: ..
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x20000
  memory RVCT4: ROM 0x3000000 size 0x2000
  memory RVCT5: ROM 0x13000000 size 0x2000
  memory RVCT6: RAM 0x4000000 size 0x2000
  memory RVCT7: RAM 0x14000000 size 0x2000
  memory RVCT8: RAM 0x4002000 size 0x1000
  memory RVCT9: RAM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x6000
  scatter file: MCXA153_flash.scf
  link misc: --remove --entry=Reset_Handler --diag_suppress 6314
  group source
    ../: FreeRTOSConfig.h freertos_sem.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.md
  group freertos/freertos-kernel/portable/GCC/ARM_CM33_NTZ/non_secure
    ../../../../../rtos/freertos/freertos-kernel/portable/GCC/ARM_CM33_NTZ/non_secure/: port.c portasm.c portasm.h portmacro.h portmacrocommon.h
  group freertos/freertos-kernel/portable/MemMang
    ../../../../../rtos/freertos/freertos-kernel/portable/MemMang/: heap_4.c ReadMe.url
  group drivers
    ../../../../../devices/MCXA153/drivers/: fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_lpuart.h fsl_lpuart.c fsl_gpio.h fsl_gpio.c fsl_port.h fsl_inputmux_connections.h fsl_reset.h fsl_reset.c fsl_spc.h fsl_spc.c
  group device
    ../../../../../devices/MCXA153/: fsl_device_registers.h MCXA153.h MCXA153_features.h system_MCXA153.c system_MCXA153.h
  group startup
    ../../../../../devices/MCXA153/arm/: startup_MCXA153.S
  group utilities
    ../../../../../devices/MCXA153/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MCXA153/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group freertos/freertos-kernel
    ../../../../../rtos/freertos/freertos-kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos-kernel/include
    ../../../../../rtos/freertos/freertos-kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group freertos/freertos-kernel/portable
    ../../../../../rtos/freertos/freertos-kernel/portable/: readme.txt
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
target freertos_sem release (6130001::V6.13.1::.\ARMCLANG)
  device: MCXA153VLH NXP
  pack: NXP.MCXA153_DFP.17.0.0
  cpu: CPUTYPE("Cortex-M33")
  output: freertos_sem.out
  AfterMake: fromelf.exe --output "$Lfreertos_sem.bin" --bincombined "#L"
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, CPU_MCXA153VLH, MCUXPRESSO_SDK, SDK_OS_FREE_RTOS
  c misc: as above
  c include: as above
  asm define: CPU_LPC55S69JBD100_cm33_core0, NDEBUG,__CC_ARM,KEIL, NDEBUG
  asm include: ..
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x20000
  memory RVCT4: ROM 0x3000000 size 0x2000
  memory RVCT5: ROM 0x13000000 size 0x2000
  memory RVCT6: RAM 0x4000000 size 0x2000
  memory RVCT7: RAM 0x14000000 size 0x2000
  memory RVCT8: RAM 0x4002000 size 0x1000
  memory RVCT9: RAM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x6000
  scatter file: MCXA153_flash.scf
  link misc: --remove --entry=Reset_Handler --diag_suppress 6314
